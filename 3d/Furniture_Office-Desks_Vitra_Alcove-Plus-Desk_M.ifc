Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-05-18T18:16:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 18 18:16:07 2021 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{002A6415-BEF8-4745-BF46-AB6B30FF089C}\ifc * Database version: 5507 * Database creation date: Tue May 18 18:16:06 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 18 18:16:06 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 18 18:16:06 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Alcove Plus Desk Medium, Furniture_Office-Desks_Vitra_Alcove-Plus-Desk_M:Alcove Plus Desk Medium:415446
In: Level 1
Type - Material: Table light oak, 01 chrome, Textile laser yellow pastel green 23
Type - Dimensions - NominalDepth: 860 mm; NominalHeight: 1367 mm; NominalLength: 1245 mm
Type - General - Author: BIMStone; BIMObjectName: Furniture_Office-Desks_Vitra_Alcove-Plus-Desk_M; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office desks; NBSReference: 45-35-20/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_21_21; Uniclass2015Description: Desks; Uniclass2015Reference: Pr_40_50_21_21; Version: 1; VersionDate: 07/05/2021
Type - Identity Data - Collection: Alcove Plus; Cost: 0; Designer: Ronan & Erwan Bouroullec; Manufacturer: Vitra; Model: Alcove Plus Desk Medium; OmniClass Number: 23.40.20.24.31; OmniClass Title: Desk; Type Name: Alcove Plus Desk Medium
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Desk; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Office-Desks_Vitra_Alcove-Plus-Desk_M; Features: n/a; Finish: n/a; Grade: n/a; Material: Polyurethane foam, polyester fibre, steel & MDF; ModelNumber: n/a; ModelReference: n/a; Name: Alcove-Plus-Desk_M; ReplacementCost: n/a; Shape: Sculptured; Size: 1245x860x1367 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - LeftRightOrientation: no; MetaProperties_TableTopVersion: Without Cable Outlet; TableTopCut: no
Dimensions - Area: 3.94823 m2; Volume: 1.46365 m3
Materials and Finishes - CoverMaterial: Textile laser yellow pastel green 23; FrameMaterial: 01 chrome; TableTopMaterial: Table light oak
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Office-Desks_Vitra_Alcove-Plus-Desk_M: Alcove Plus Desk Medium; Family and Type: Furniture_Office-Desks_Vitra_Alcove-Plus-Desk_M: Alcove Plus Desk Medium; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Office-Desks_Vitra_Alcove-Plus-Desk_M: Alcove Plus Desk Medium; Type Id: Furniture_Office-Desks_Vitra_Alcove-Plus-Desk_M: Alcove Plus Desk Medium; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
